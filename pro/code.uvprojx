# Keil uVision project code.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.2.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: code +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32E230
  c misc: -Wno-covered-switch-default
  c include: ..\app;..\pro;..\bsp\gd32e230c_eval;..\bsp\systick;..\lib\CMSIS\GD\GD32E23x\Include;..\lib\GD32E23x_standard_peripheral\Include;..\bsp\system_gd32e23x;..\lib\GD32E23x_standard_peripheral\Source;..\lib\CMSIS\GD\GD32E23x\Source;..\lib\CMSIS\GD\GD32E23x\Source\ARM;..\lib\CMSIS;..\bsp\Timeout;..\bsp\uart_decoder;..\bsp\flash;..\bsp\customer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group pro
    ./: main.c
    ../lib/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group app
    ../app/: gd32e23x_it.c app.c user_cfg.c app_realcheck.c app_common.c key_touch_process.c app_meter.c app_chargectl.c app_mainctl.c
  group bsp
    ../bsp/gd32e230c_eval/: gd32e230c_eval.c
    ../bsp/systick/: systick.c
    ../bsp/system_gd32e23x/: system_gd32e23x.c
    ../bsp/Timeout/: TimeOut.c
    ../bsp/flash/: bsp_flash.c
    ../bsp/customer/: hw_api_usart.c drv_common.c bsp_oled.c bsp_meter_v9260.c bsp_led.c app_target.c
  group lib
    ../lib/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
software components: CMSIS:CORE 6.1.0
